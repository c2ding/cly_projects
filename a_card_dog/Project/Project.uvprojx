# Keil uVision project Project.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Debug
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,USE_FULL_ASSERT
  c misc: --C99
  c include: ..\DeviceDrivers\Libraries\STM32F1xx_HAL_Driver\Inc\Legacy;..\DeviceDrivers\Libraries\STM32F1xx_HAL_Driver\Inc;..\DeviceDrivers\Libraries\CMSIS\Include;..\DeviceDrivers\Libraries\CMSIS\Device\ST\STM32F1xx\Include;..\DeviceDrivers\Extended\inc;..\DeviceDrivers\Internal\inc;..\Application\inc;..\DeviceDrivers\FatFs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../Application/scr/: entrance.c application.c
  group drive_extended
    ../DeviceDrivers/Extended/src/: stm32f1xx_delay.s stm32f1xx_system_led.c
  group drive_internal
    ../DeviceDrivers/Internal/src/: stm32f1xx_hal_msp.c stm32f1xx_it.c stm32f1xx_usart1.c stm32f1xx_usart2.c stm32f1xx_usart3.c stm32f1xx_uart4.c stm32f1xx_uart5.c stm32f1xx_can.c stm32f1xx_i2c1.c stm32f1xx_i2c2.c stm32f1xx_spi1.c stm32f1xx_spi2.c stm32f1xx_spi3.c stm32f1xx_adc1.c stm32f1xx_adc2.c stm32f1xx_adc3.c stm32f1xx_dac.c stm32f1xx_tim1.c stm32f1xx_tim2.c stm32f1xx_tim3.c stm32f1xx_tim4.c stm32f1xx_tim5.c stm32f1xx_tim6.c stm32f1xx_tim7.c stm32f1xx_tim8.c stm32f1xx_flash.c
  group CORTEX-M3
    ../DeviceDrivers/Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../DeviceDrivers/Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f100xb.s startup_stm32f100xe.s startup_stm32f101x6.s startup_stm32f101xb.s startup_stm32f101xe.s startup_stm32f101xg.s startup_stm32f102x6.s startup_stm32f102xb.s startup_stm32f103x6.s startup_stm32f103xb.s startup_stm32f103xe.s startup_stm32f103xg.s startup_stm32f105xc.s startup_stm32f107xc.s
  group STM32F1xx_HAL_Driver
    ../DeviceDrivers/Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal_sd.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_wwdg.c
  group readme
    ../Readme/: modify.txt readme.txt
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Release +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
